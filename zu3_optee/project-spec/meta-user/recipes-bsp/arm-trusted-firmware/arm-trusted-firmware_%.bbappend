EXTRA_OEMAKE:append:zynqmp = " SPD=opteed BL32_BASE=0x1E000000"
