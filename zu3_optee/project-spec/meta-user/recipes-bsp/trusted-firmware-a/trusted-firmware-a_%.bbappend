EXTRA_OEMAKE:append:zynqmp = " SPD=opteed BL32_BASE=0x1E000000 BL32_MEM_BASE=0x1E000000 BL32_SIZE=0x02000000 BL32_MEM_SIZE=0x02000000 ZYNQMP_BL32_MEM_BASE=0x1E000000 ZYNQMP_BL32_MEM_SIZE=0x02000000"
DEBUG_ATF = "1"
