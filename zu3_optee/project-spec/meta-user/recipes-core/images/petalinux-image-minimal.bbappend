IMAGE_INSTALL:append = " secure-switch"
