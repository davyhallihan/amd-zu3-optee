COMPATIBLE_MACHINE:zynqmp = ".*"
